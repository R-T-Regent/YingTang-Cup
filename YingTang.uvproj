# Keil uVision project YingTang.uvproj, settings and files
target YingTang (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: YingTang +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user;.\FF9
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ./startup/: startup_stm32f10x_hd.s
  group UESR
    ./user/: stm32f10x_it.c main.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_usart.c
  group CMSIS
    ./user/: core_cm3.c system_stm32f10x.c
  group BSP
    ./user/: delay.c bsp_ov7725.c bsp_sccb.c bsp_ili9341.c bsp_tftGUI.c bsp_sdcard.c bsp_usart.c
  group FATFS.09
    ./FF9/: ff.c diskio.c
